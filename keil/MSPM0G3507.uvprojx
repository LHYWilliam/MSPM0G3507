# Keil uVision project MSPM0G3507.uvprojx, settings and files
target MSPM0G3507 (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MSPM0G3507 +hex
  BeforeMake: cmd.exe /C "C:/ti/mspm0_sdk_2_01_00_03/tools/keilUser/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\system;..\hardware;..\util;..\core;..\driverlib;..\..\MSPM0G3507;C:\ti\mspm0_sdk_2_01_00_03\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  group Source
    ../: main.c empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group System
    ../system/: serial.c serial.h
  group HardWare
    ../hardware/: key.c key.h LED.c LED.h motor.c motor.h OLED.c OLED.h OLED_Font.h
  group Util
    ../util/: delay.c delay.h pid.c pid.h
  group MPU
    ../mpu/: dmp.c dmp.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu.c mpu.h mpui2c.c mpui2c.h
  group Core
    ../core/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm0plus.h mpu_armv7.h
  group DriverLib
    ../driverlib/: dl_adc12.c dl_adc12.h dl_aes.c dl_aes.h dl_aesadv.c dl_aesadv.h dl_common.c dl_common.h dl_comp.h dl_crc.c dl_crc.h dl_crcp.c dl_crcp.h dl_dac12.c dl_dac12.h dl_dma.c dl_dma.h dl_flashctl.c dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.c dl_i2c.h dl_iwdt.h dl_keystorectl.c dl_keystorectl.h dl_lcd.c dl_lcd.h dl_lfss.c dl_lfss.h dl_mathacl.c dl_mathacl.h dl_mcan.c dl_mcan.h dl_opa.c dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_common.c dl_rtc_common.h dl_scratchpad.h dl_spi.c dl_spi.h dl_tamperio.h dl_timer.c dl_timer.h dl_timera.h dl_timerg.h dl_trng.c dl_trng.h dl_uart.c dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.c dl_vref.h dl_wwdt.h driverlib.h
